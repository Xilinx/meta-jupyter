inherit pypi setuptools
require python-jedi.inc
