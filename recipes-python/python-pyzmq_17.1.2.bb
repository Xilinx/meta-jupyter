inherit pypi setuptools
require python-pyzmq.inc
