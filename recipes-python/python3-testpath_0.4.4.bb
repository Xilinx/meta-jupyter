inherit pypi setuptools3
require python-testpath.inc

SRC_URI[md5sum] = "297100d49a6f20859383434a182cf426"
SRC_URI[sha256sum] = "60e0a3261c149755f4399a1fff7d37523179a70fdc3abdf78de9fc2604aeec7e"

