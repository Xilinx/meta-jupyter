inherit pypi setuptools3
require python-jupyterlab.inc
