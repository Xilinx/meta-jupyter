inherit pypi setuptools3
SUMMARY = "Client library to execute notebooks"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=438c1b61bd5f6170c2203d10749c99d2"

SRC_URI[sha256sum] = "751516992f34b58172bad54eef1e4bf7e4f4460d58e255ca1a4e5c9649476007"
