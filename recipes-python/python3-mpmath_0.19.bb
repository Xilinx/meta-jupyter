inherit pypi setuptools3
require python-mpmath.inc
