inherit pypi setuptools
require python-terminado.inc
