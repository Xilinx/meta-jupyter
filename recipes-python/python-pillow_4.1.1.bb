inherit setuptools
require python-pillow.inc
