inherit pypi setuptools3
require python-kiwisolver.inc
