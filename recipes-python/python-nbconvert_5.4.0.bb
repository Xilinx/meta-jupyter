inherit pypi setuptools
require python-nbconvert.inc
