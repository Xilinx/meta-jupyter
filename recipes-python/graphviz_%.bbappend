pkg_postinst_ontarget_${PN}() {
  /usr/bin/dot -c
}
