inherit pypi setuptools3

SUMMARY = "making Python packages with and without accompanying JavaScript packages"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=3acab95fd69e0d08e339a87b8bc1081f"

PYPI_PACKAGE="jupyter-packaging"
PN="python3-jupyter_packaging"
BBCLASSEXTEND = "native"

SRC_URI[md5sum] = "ce750636406bbf37f59f532379c926e0"
SRC_URI[sha256sum] = "2ded75723372e5ced2e1be1ee85506c88895518892f20eacc3b3a344cf59ce3a"
