inherit pypi setuptools3
require python-ipywidgets.inc
