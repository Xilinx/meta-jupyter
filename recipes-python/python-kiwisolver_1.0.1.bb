inherit pypi setuptools
require python-kiwisolver.inc
