inherit pypi setuptools
require python-scandir.inc
