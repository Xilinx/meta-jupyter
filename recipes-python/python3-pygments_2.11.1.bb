inherit pypi setuptools3

SUMMARY = "Pygments is a syntax highlighting package written in Python"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://PKG-INFO;beginline=8;endline=8;md5=88df8e78b9edfd744953862179f2d14e"

BBCLASSEXTEND = "native"

PYPI_PACKAGE = "Pygments"

SRC_URI[sha256sum] = "59b895e326f0fb0d733fd28c6839bd18ad0687ba20efc26d4277fd1d30b971f4"
