inherit pypi setuptools3
require python-mistune.inc
