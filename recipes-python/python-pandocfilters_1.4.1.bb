inherit pypi setuptools
require python-pandocfilters.inc
