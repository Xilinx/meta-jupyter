inherit pypi setuptools
require python-pickleshare.inc
