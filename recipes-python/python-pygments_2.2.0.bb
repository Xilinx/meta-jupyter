inherit pypi setuptools
require python-pygments.inc
