inherit pypi setuptools3
require python-nbconvert.inc
