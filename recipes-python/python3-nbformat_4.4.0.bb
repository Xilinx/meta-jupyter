inherit pypi setuptools3
require python-nbformat.inc
