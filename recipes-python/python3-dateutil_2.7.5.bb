inherit pypi setuptools3
require python-dateutil.inc
