inherit pypi setuptools
require python-backcall.inc
