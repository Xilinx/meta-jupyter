SUMMARY = "Client library to execute notebooks"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=438c1b61bd5f6170c2203d10749c99d2"

SRC_URI[sha256sum] = "0df76a7961d99a681b4796c74a1f2553b9f998851acc01896dce064ad19a9027"
PYPI_PACKAGE = "nbclient"

inherit pypi setuptools3