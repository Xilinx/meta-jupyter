inherit pypi setuptools3
require python-send2trash.inc
