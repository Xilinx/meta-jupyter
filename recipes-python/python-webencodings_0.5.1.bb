inherit pypi setuptools
require python-webencodings.inc
