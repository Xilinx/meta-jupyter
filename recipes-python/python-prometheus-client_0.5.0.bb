inherit pypi setuptools
require python-prometheus-client.inc
