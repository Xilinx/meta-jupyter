inherit pypi setuptools3
require python-widgetsnbextension.inc
