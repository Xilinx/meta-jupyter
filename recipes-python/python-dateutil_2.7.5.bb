inherit pypi setuptools
require python-dateutil.inc
