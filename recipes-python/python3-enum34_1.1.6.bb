inherit pypi setuptools3
require python-enum34.inc
