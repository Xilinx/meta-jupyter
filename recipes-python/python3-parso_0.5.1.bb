inherit pypi setuptools3
require python-parso.inc
