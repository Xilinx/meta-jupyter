inherit pypi setuptools
require python-entrypoints.inc
