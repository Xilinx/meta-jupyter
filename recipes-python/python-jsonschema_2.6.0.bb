inherit pypi setuptools
require python-jsonschema.inc
