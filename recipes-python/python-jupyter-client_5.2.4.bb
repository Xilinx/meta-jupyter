inherit pypi setuptools
require python-jupyter-client.inc
