SUMMARY = "Vestigial utilities from IPython"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://PKG-INFO;beginline=8;endline=8;md5=e910b35b0ef4e1f665b9a75d6afb7709"

SRC_URI[md5sum] = "9a8afbe0978adbcbfcb3b35b2d015a56"
SRC_URI[sha256sum] = "3a0624a251a26463c9dfa0ffa635ec51c4265380980d9a50d65611c3c2bd82a6"

PYPI_PACKAGE = "ipython_genutils"

inherit pypi setuptools
