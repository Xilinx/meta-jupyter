inherit pypi setuptools
require python-nbformat.inc
