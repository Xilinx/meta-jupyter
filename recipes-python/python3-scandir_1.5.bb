inherit pypi setuptools3
require python-scandir.inc
