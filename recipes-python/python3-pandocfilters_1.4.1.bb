inherit pypi setuptools3
require python-pandocfilters.inc
