inherit pypi setuptools3
require python-defusedxml.inc
