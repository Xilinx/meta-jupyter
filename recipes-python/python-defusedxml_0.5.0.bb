inherit pypi setuptools
require python-defusedxml.inc
