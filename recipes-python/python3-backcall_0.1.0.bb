inherit pypi setuptools3

SUMMARY = "Backcall: Specifications for callback functions passed in to an API"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://PKG-INFO;beginline=8;endline=8;md5=e910b35b0ef4e1f665b9a75d6afb7709"
BBCLASSEXTEND = "native"

SRC_URI[sha256sum] = "bbbf4b1e5cd2bdb08f915895b51081c041bac22394fdfcfdfbe9f14b77c08bf2"

PYPI_PACKAGE_EXT = "zip"

