inherit pypi setuptools3
require python-notebook.inc

SRC_URI[md5sum] = "a2292ca8d26f98cf7b202ba4fb484707"
SRC_URI[sha256sum] = "399a4411e171170173344761e7fd4491a3625659881f76ce47c50231ed714d9b"
