inherit pypi setuptools
require python-ipython-genutils.inc
