inherit pypi setuptools
require python-jupyterlab-server.inc
