inherit pypi setuptools3
require python-ipykernel.inc
