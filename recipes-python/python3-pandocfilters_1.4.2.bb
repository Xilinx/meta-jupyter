inherit pypi setuptools3
require python-pandocfilters.inc

SRC_URI[md5sum] = "dc391791ef54c7de1572d7b46b63361f"
SRC_URI[sha256sum] = "b3dd70e169bb5449e6bc6ff96aea89c5eea8c5f6ab5e207fc2f521a2cf4a0da9"
