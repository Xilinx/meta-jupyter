inherit pypi setuptools
require python-parso.inc
