inherit pypi setuptools3
require python-backports-shutil-get-terminal-size.inc
