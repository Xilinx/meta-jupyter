inherit pypi setuptools3

SUMMARY = "Pygments is a syntax highlighting package written in Python"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://PKG-INFO;beginline=8;endline=8;md5=88df8e78b9edfd744953862179f2d14e"

BBCLASSEXTEND = "native"

PYPI_PACKAGE = "Pygments"

SRC_URI[md5sum] = "a48c5219de92f12c41acba814730b31a"
SRC_URI[sha256sum] = "647344a061c249a3b74e230c739f434d7ea4d8b1d5f3721bc0f3558049b38f44"
