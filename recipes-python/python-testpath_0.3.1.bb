SUMMARY = "Test utilities for code working with files and commands"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://PKG-INFO;beginline=8;endline=8;md5=d41d8cd98f00b204e9800998ecf8427e"

SRC_URI[md5sum] = "2cd5ed5522fda781bb497c9d80ae2fc9"
SRC_URI[sha256sum] = "0d5337839c788da5900df70f8e01015aec141aa3fe7936cb0d0a2953f7ac7609"

PYPI_PACKAGE = "testpath"

inherit pypi setuptools
