inherit pypi setuptools3
require python-webencodings.inc
