inherit pypi setuptools
require python-ipywidgets.inc
