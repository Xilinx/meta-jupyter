inherit pypi setuptools
require python-mistune.inc
