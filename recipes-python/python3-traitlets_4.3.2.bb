inherit pypi setuptools3
require python-traitlets.inc
