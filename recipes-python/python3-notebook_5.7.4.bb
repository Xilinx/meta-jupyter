inherit pypi setuptools3
require python-notebook.inc
