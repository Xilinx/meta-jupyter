inherit pypi setuptools3
require python-ptyprocess.inc
