inherit pypi setuptools3

SUMMARY = "Pygments is a syntax highlighting package written in Python"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://PKG-INFO;beginline=8;endline=8;md5=88df8e78b9edfd744953862179f2d14e"

BBCLASSEXTEND = "native"

PYPI_PACKAGE = "Pygments"

SRC_URI[md5sum] = "5ecc3fbb2a783e917b369271fc0e6cd1"
SRC_URI[sha256sum] = "881c4c157e45f30af185c1ffe8d549d48ac9127433f2c380c24b84572ad66297"
