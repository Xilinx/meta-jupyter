inherit pypi setuptools3
require python-prompt-toolkit.inc
