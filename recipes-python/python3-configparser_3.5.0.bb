inherit pypi setuptools3
require python-configparser.inc
