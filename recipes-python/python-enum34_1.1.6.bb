inherit pypi setuptools
require python-enum34.inc
