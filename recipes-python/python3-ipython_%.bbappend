BBCLASSEXTEND = "native"

RDEPENDS:${PN} += " ${PYTHON_PN}-stack-data "
