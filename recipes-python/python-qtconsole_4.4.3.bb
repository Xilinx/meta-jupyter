inherit pypi setuptools
require python-qtconsole.inc
