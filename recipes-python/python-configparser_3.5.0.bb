SUMMARY = "Discover and load entry points from installed packages"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://PKG-INFO;beginline=8;endline=8;md5=8227180126797a0148f94f483f3e1489"

SRC_URI[md5sum] = "cfdd915a5b7a6c09917a64a573140538"
SRC_URI[sha256sum] = "5308b47021bc2340965c371f0f058cc6971a04502638d4244225c49d80db273a"

PYPI_PACKAGE = "configparser"

inherit pypi setuptools
