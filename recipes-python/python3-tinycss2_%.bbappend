# tinycss2 imports webencodings at module scope
RDEPENDS:${PN} += "python3-webencodings"
