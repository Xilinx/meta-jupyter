inherit pypi setuptools3
require python-singledispatch.inc
