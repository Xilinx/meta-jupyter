inherit pypi setuptools3
require python-mpmath.inc

SRC_URI[md5sum] = "acb1cdddf38e16084628065b174ddbfe"
SRC_URI[sha256sum] = "fc17abe05fbab3382b61a123c398508183406fa132e0223874578e20946499f6"
