SUMMARY = "Simple generic functions"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://PKG-INFO;beginline=8;endline=8;md5=a1f58ef94ce0dd754b603f0479e193ad"

SRC_URI[md5sum] = "f9c1fab00fd981be588fc32759f474e3"
#SRC_URI[sha256sum] = "3e1f86076bbb7c8c207829390305a2b1fe836d471ed54be66a3b8c41e7f46cc7"

PYPI_PACKAGE_EXT = "zip"

inherit pypi setuptools
