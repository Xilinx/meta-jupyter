inherit pypi setuptools
require python-ptyprocess.inc
