inherit pypi setuptools3
require python-qtconsole.inc
