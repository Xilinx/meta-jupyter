inherit pypi setuptools
require python-widgetsnbextension.inc
