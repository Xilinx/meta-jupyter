inherit pypi setuptools3
require python-jupyterlab-server.inc
