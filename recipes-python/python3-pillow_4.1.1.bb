inherit setuptools3
require python-pillow.inc

