inherit pypi setuptools
require python-jupyter.inc
