inherit pypi setuptools3
require python-simplegeneric.inc
