inherit pypi setuptools3
require python-terminado.inc
