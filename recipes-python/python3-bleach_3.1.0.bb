inherit pypi setuptools3
require python-bleach.inc
