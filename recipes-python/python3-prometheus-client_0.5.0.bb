inherit pypi setuptools3
require python-prometheus-client.inc
