inherit pypi setuptools
require python-ipython.inc

SRC_URI[md5sum] = "ccf4f85bab1b086a439c1f9256e30c9a"
SRC_URI[sha256sum] = "8db43a7fb7619037c98626613ff08d03dda9d5d12c84814a4504c78c0da8323c"
