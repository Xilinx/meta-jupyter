inherit pypi setuptools3

SUMMARY = "scandir, a better directory iterator and faster os.walk()"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=482ee62da51806409d432a80eed4e3ea"

BBCLASSEXTEND = "native"

SRC_URI[md5sum] = "f8378f4d9f95a6a78e97ab01aa900c1d"
SRC_URI[sha256sum] = "4d4631f6062e658e9007ab3149a9b914f3548cb38bfb021c64f39a025ce578ae"

