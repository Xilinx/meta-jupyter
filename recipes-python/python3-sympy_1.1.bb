inherit pypi setuptools3
require python-sympy.inc
