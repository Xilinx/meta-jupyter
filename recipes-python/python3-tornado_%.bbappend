BBCLASSEXTEND = "native"
RDEPENDS:${PN}:class-native = ""
