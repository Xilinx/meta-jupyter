inherit pypi setuptools3
require python-pyzmq.inc
