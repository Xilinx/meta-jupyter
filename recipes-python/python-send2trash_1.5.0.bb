inherit pypi setuptools
require python-send2trash.inc
