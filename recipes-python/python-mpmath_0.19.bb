inherit pypi setuptools
require python-mpmath.inc
