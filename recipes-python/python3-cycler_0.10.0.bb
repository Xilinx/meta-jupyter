inherit pypi setuptools3
require python-cycler.inc
