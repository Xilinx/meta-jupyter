inherit pypi setuptools
require python-cycler.inc
