SUMMARY = "A backport of recent additions to the 'collections.abc' module"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://PKG-INFO;beginline=8;endline=8;md5=23f9ad5cad3d8cc0336e2a5d8a87e1fa"

SRC_URI[md5sum] = "7d1936ec183a3586290adf60f6f96764"
SRC_URI[sha256sum] = "033be54514a03e255df75c5aee8f9e672f663f93abb723444caec8fe43437bde"

PYPI_PACKAGE = "backports_abc"

inherit pypi setuptools
