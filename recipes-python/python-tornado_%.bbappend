RDEPENDS_${PN} += " \
	python-singledispatch \
	python-certifi \
	python-backports-abc \
	"