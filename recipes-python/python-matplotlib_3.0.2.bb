inherit pypi setuptools
require python-matplotlib.inc

