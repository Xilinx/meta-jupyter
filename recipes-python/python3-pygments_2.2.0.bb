inherit pypi setuptools3
require python-pygments.inc
