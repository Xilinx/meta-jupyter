inherit pypi setuptools
require python-jupyterlab.inc

LIC_FILES_CHKSUM = "file://LICENSE;md5=dae23fe35f1b4a29dcb6818e9b4e4cc2"

SRC_URI[md5sum] = "5deef5d09fd497d8aff7ec6851ac4ec9"
SRC_URI[sha256sum] = "22a1913f8251b7cc6b3a4a5527017b9ecf612df5f96ac1805f762894794e1344"
