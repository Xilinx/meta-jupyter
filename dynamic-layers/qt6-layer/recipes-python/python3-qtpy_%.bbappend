RRECOMMENDS:${PN} = "python3-pyqt6"
